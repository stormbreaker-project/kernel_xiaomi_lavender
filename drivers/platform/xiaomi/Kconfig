## drivers/platform/xiaomi/Kconfig
```kconfig
# Xiaomi newcam option

config XIAOMI_NEWCAM
        bool "Xiaomi new camera blobs"
        help
          Support for new camera blobs
```
